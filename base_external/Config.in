## base_external/Config.in
```kconfig
menu "External options"
   source "/home/linux-o-phile/assignment-4-jainaneesh/base_external/package/aesd-assignments/Config.in"
endmenu
```
